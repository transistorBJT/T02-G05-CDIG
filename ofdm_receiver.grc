options:
  parameters:
    generate_options: qt_gui
    id: frame_detection
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {state: disabled}
- name: window_size
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '10'
    step: '1'
    stop: '100'
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '240'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dcastro/projeto_cdig/captures/captura1.pcap
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/live_capture.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dcastro/projeto_cdig/Wifi_Project_Baseband_recordings/Sample3_20MHz_Channel100.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.1*variable_qtgui_range_0
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    \"\"\"\n    SSID Detector Block\n    Recebe PDUs do WiFi Parse MAC e procura um SSID específico\n    \"\"\"\n\n    def __init__(self, target_ssid=\"MyNetwork\"):\n        gr.basic_block.__init__(\n            self,\n            name=\"SSID Detector\",\n            in_sig=None,\n            out_sig=None,\n        )\n\n        self.target_ssid = target_ssid\n\n        # Porta de entrada: recebe PDUs do WiFi Parse MAC\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n        # Porta de saída: emite mensagem \"found\" quando encontra o SSID\n        self.message_port_register_out(pmt.intern(\"found\"))\n\n    def handle_msg(self, msg):\n        \"\"\"\n        msg é um PDU: (metadata, u8vector payload)\n        \"\"\"\n\n        meta = pmt.car(msg)\n        body = pmt.cdr(msg)\n\n        if not pmt.is_u8vector(body):\n            return\n\n        frame = bytes(pmt.u8vector_elements(body))\n\n        # Os management frames (e beacons) têm pelo menos 36 bytes\n        if len(frame) < 36:\n            return\n\n        # Frame Control\n        fc = frame[0]\n        type_val = (fc >> 2) & 0x03\n        subtype_val = (fc >> 4) & 0x0F\n\n        # Só queremos Management frames\n        if type_val != 0:\n            return\n\n        # Beacon (subtype 8) ou Probe Response (subtype 5)\n        if subtype_val not in [8, 5]:\n            return\n\n        # Management frames têm 12 bytes de \"fixed parameters\" após cabeçalhos\n        # IEs começam normalmente em offset 36\n        ie_offset = 36\n        i = ie_offset\n\n        while i < len(frame) - 2:\n            element_id = frame[i]\n            length = frame[i + 1]\n\n            if i + 2 + length > len(frame):\n                return  # IE inconsistente → abortar\n\n            # SSID IE → Element ID = 0\n            if element_id == 0:\n                ssid_bytes = frame[i + 2 : i + 2 + length]\n                try:\n                    ssid = ssid_bytes.decode(errors=\"ignore\")\n                except:\n                    ssid = \"\"\n\n                if ssid == self.target_ssid:\n                    print(f\"[SSID Detector] SSID encontrado: '{ssid}'\")\n                    # Enviar aviso (mensagem vazia tipo PMT_T)\n                    self.message_port_pub(pmt.intern(\"found\"), pmt.PMT_T)\n\n                return  # Encontrado ou não, sair do bloco\n\n            # Avançar para o próximo IE\n            i += 2 + length\n\n"
    target_ssid: '"raspberrypi"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: fff
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: '3'
    bw: 10e6
    debug: 'False'
    freq: 5.89e9
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '240'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.8'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '5180000000'
    gain1: '''manual'''
    manual_gain1: variable_qtgui_range_0
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 172.24.64.1
    mtu: '10000'
    port: '52001'
    type: UDP_CLIENT
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '480'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.05'
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '512'
    srate: samp_rate
    tr_delay: '0.000005'
    tr_level: '0.93'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.5'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e6
    fc: 5.5e9
    fftsize: '1024'
    type: complex
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_1, '0', ieee802_11_sync_long_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0, '0', ieee802_11_sync_short_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_divide_xx_0, '1']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_1, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_parse_mac_0, out, epy_block_0, in]
- [ieee802_11_parse_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_parse_mac_0, out, network_socket_pdu_0, pdus]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_1, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [ieee802_11_sync_short_0, '0', qtgui_time_sink_x_1, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '1']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
